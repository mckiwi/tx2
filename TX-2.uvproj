# Keil uVision project TX-2.uvproj, settings and files
target TX-2 (MCS-51)
  device: MPC82G516A Megawin
  cpu: IRAM(0 - 0xFF) XRAM(0x0-0x3FF) IROM(0 - 0x3FFF) CLOCK(45000000)
  output: TX-2_20241007-IOEXP_MCUBD +hex
  c flags: SizeSpeed=1
  group TX-2
    ./: TX-2.C FastKey.c ScanKeyAction.C PWM.C RS232.C Eep24C04.c NJW1159.C IOEXP6524.c
